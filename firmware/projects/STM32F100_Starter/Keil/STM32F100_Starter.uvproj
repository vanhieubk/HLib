# Keil uVision project STM32F100_Starter.uvproj, settings and files
target STM32F100_Starter (ARM-ADS)
  device: STM32F100C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F100_Starter +hex
  c flags: Optim=1
  c include: ..\..\..\st_lib\stm32f1xx\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\st_lib\stm32f1xx\inc;..\..\..\hlib\inc;..\..\..\user_libs\inc;.\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../st_lib/stm32f1xx/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../st_lib/stm32f1xx/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_ld_vl.s
  group st_lib
    ../../../st_lib/stm32f1xx/src/: misc.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_spi.c
  group hlib
    ../../../hlib/scr/: hl_clk.cpp hl_crc.cpp hl_led.cpp hl_pin.cpp hl_pin_ll.cpp hl_spi_base.cpp hl_uart.cpp hl_util.cpp hlib.cpp hl_adc.cpp
  group app
    ./src/: app.cpp
