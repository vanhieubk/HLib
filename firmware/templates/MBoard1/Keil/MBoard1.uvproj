# Keil uVision project MBoard1.uvproj, settings and files
target MBoard1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MBoard1 +hex
  c flags: Optim=1
  c include: ..\..\..\st_lib\stm32f1xx\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\st_lib\stm32f1xx\inc;..\..\..\hlib\inc;..\..\..\user_libs\inc;.\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../../../st_lib/stm32f1xx/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../st_lib/stm32f1xx/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group st_lib
    ../../../st_lib/stm32f1xx/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hlib
    ../../../hlib/scr/: hl_pins_c.cpp hl_uart_c.cpp hl_util.cpp hlib.cpp hl_leds_c.cpp hl_spi_i2s_c.cpp hl_adc_c.cpp
  group user_libs
    ../../../user_libs/src/: tmp121_c.cpp tlc5971_c.cpp
  group app
    ./src/: app.cpp
