# Keil uVision project STM32F100_Starter.uvproj, settings and files
target STM32F100_Starter (ARM-ADS)
  device: STM32F100C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F100_Starter +hex
  c flags: Optim=1
  c include: ..\..\..\st_lib\stm32f1xx\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\st_lib\stm32f1xx\inc;..\..\..\hlib\inc;..\..\..\user_libs\inc;.\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../st_lib/stm32f1xx/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../st_lib/stm32f1xx/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_ld_vl.s
  group st_lib
    ../../../st_lib/stm32f1xx/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hlib
    ../../../hlib/scr/: hlib.cpp hl_uart_c.cpp hl_leds_c.cpp hl_pins_c.cpp hl_hd44780_c.cpp hl_util.cpp hl_spi_i2s_c.cpp
  group app
    ./src/: app.cpp
